# Keil uVision project SN_debug.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CanStm32 +hex
  AfterMake: D:\Keil\ARM\BIN40\fromelf.exe --bin -o ..\IAP\CanStm32.bin ..\OBJ\CanStm32.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_SN_DEBUG_
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\UCOSII\CORE;..\UCOSII\PORT;..\APP;..\UCOSII\CONFIG;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: moto.c FuncLayout.c KeyAdc.c KeyProc.c main.c Menu.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: Font.c ILI93xx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group uC/OS-II CORE
    ../UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C os_tmr.c
  group uC/OS-II PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC/OS-II CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
