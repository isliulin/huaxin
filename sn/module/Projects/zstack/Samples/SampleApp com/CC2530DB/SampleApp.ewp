# IAR project SampleApp.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2530.i51
  ICC8051.CCDefines: ZIGBEEPRO; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; xMT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; NV_RESTORE
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\..\Tools\CC2530DB\oad.exe" "CoordinatorEB\Exe\SampleApp.sim" "CoordinatorEB\Exe\SampleApp.bin"
  XLINK.XclFile: D:\WorkReserve\project\NewStep\CanMstOsal\Projects\zstack\Tools\CC2530DB\oad.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration DemoEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: BUILD_ALL_DEVICES; HOLD_AUTO_START; LCD_SUPPORTED; HAL_UART=FALSE
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration CoordinatorEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; ZTOOL_P1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP; ..\..\..\..\..\COMPONENTS\usb\library; ..\..\..\..\..\COMPONENTS\usb\class_hid; ..\..\..\..\..\COMPONENTS\hal\common
  postbuild: "..\..\..\Tools\CC2530DB\oad.exe" "CoordinatorEB-Pro\Exe\SampleApp.sim" "CoordinatorEB-Pro\Exe\SampleApp.bin"
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\oad.xcl
configuration RouterEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration EndDeviceEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration DemoEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; BUILD_ALL_DEVICES; HOLD_AUTO_START; LCD_SUPPORTED; HAL_UART=FALSE
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
  group App
    ../Source/: OSAL_SampleApp.c SampleApp.c SampleApp.h SampleAppHw.h
    Source/: SampleAppHw.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c hal_int.c
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../Components/hal/include/: hal_ccm.h
  group HAL/Target/CC2530EB/Config
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c util_buffer.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_aes.h hal_types.h
    ../../../../../Components/hal/target/CC2530EB/: hal_dma.h hal_mcu.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c
    ../../../../../COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h
    ../../../../../Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rf.c mac_rf.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_rffrontend.c
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h mac_radio_defs.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c MT.c MT_AF.c MT_AF.h MT_APP.c MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_TASK.c MT_TASK.h MT_UART.c MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
    ../../../../../COMPONENTS/mt/: DebugTrace.h MT.h MT_APP.h MT_RPC.h MT_SYS.h mt_uart.h
  group NWK
    ../../../../../COMPONENTS/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/nwk/: aps_util.h nwk_globals.c
    ../../../../../Components/stack/sys/: ZGlobals.c
    ../../../../../COMPONENTS/stack/sys/: ZGlobals.h
  group OSAL
    ../../../../../COMPONENTS/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c
    ../../../../../COMPONENTS/stack/af/: AF.h
  group Security
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/: mac_tx.h
    ../../../../../COMPONENTS/stack/sec/: ssp.h
    ../../../../../Components/stack/sec/: ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c
    ../../../../../COMPONENTS/services/saddr/: saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group USB/class_cdc
    ../../../../../Components/usb/class_cdc/: FAT.C FAT.h usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_scsi.c usb_scsi.h usb_uart.c usb_uart.h
  group USB/library
    ../../../../../COMPONENTS/usb/library/: usb_descriptor.h usb_descriptor_parser.h usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.h usb_suspend.h
    ../../../../../Components/usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group USB/library/cc2531
    ../../../../../Components/usb/library/cc2531/: hal_enter_pm.s51 usb_interrupt.c usb_suspend.c
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../../../COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDProfile.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../../../COMPONENTS/zmac/: ZMAC.h
    ../../../../../COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
