<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>FWLib</name>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\..\USER\src\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\flash_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\src\ymodem.c</name>
    </file>
  </group>
</project>


