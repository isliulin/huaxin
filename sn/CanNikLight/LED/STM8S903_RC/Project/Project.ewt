<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_awu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_tim6.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWlib\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\USER\a7105.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\uart.c</name>
    </file>
  </group>
</project>


