# IAR project CanNikLight.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CanNikLight.bin
  ILINK.IlinkOutputFile: CanNikLight.out
  ILINK.IlinkIcfFile: config\lnkstm8l152r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    hw/a7105/: a7105.c
    hw/adc/: adc.c
    aes/: aes.c
    hw/lcd/: btn.c fb.c lcd.c
    hw/eeprom/: eeprom.c
    hw/flash/: flash.c
    ./: main.c
    hw/moto/: moto.c
    hw/spi/: spi_c.c spi_n.c
    hw/sys/: sys.c
    hw/timer/: timer.c
    hw/uart/: uart.c
