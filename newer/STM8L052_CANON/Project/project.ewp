# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8L05X_HD_VL
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\Libraries\STM8L15x_StdPeriph_Driver\src; ..\Source
  ICCSTM8.IccLang: 2
  ASTM8.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: can.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Config\lnkstm8l152r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ../Config/: lnkstm8l152r8.icf
  group Header
    ../Source/: canon.h Change.h Config.h eeprom.h Funct.h includes.h Init.h Key_Process.h Lcd.h Motor.h stm8l15x_conf.h stm8l15x_it.h Task.h
  group Source
    ../Source/: canon.c Change.c eeprom.c Funct.c Init.c Key_Process.c Lcd.c Motor.c stm8l15x_it.c Task.c
    ./: main.c
  group STM8L15x_StdPeriph_Driver
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
