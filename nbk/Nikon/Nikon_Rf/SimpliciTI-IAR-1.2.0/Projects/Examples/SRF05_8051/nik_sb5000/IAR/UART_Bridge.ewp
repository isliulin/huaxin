# IAR project UART_Bridge.ewp, settings and files
configuration CC2530-LinkTo (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: MCU_H=<ioCC2530.h>; MRFI_CC2530; ZTOOL_P1; MRFI_PA_LNA_ENABLED
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\CC2530EM; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\Applications; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; ..\..\..\..\..\Components\OSAL\INCLUDE; ..\..\..\..\..\Components\OSAL\MCU\CCSOC; ..\..\..\..\..\Components\HAL\INCLUDE; ..\..\..\..\..\Components\HAL\TARGET\CC2530EB; ..\..\..\..\..\Components\SERVICES\SADDR; ..\..\..\..\..\Components\SERVICES\SDATA; ..\..\..\..\..\Components\MT; ..\..\..\..\..\Components\STACK\AF; ..\..\..\..\..\Components\STACK\NWK; ..\..\..\..\..\Components\STACK\SEC; ..\..\..\..\..\Components\STACK\SAPI; ..\..\..\..\..\Components\STACK\SYS; ..\..\..\..\..\Components\STACK\ZDO; ..\..\..\..\..\Components\MAC\INCLUDE; ..\..\..\..\..\Components\MAC\HIGH_LEVEL; ..\..\..\..\..\Components\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\Components\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: MRFI_PA_LNA_ENABLED
  postbuild: "Tools\CC2530DB\oad.exe" "LinkTo\Exe\UART_Bridge.sim" "LinkTo\Exe\SampleApp.bin"
  XLINK.XclFile: Tools\CC2530DB\oad.xcl
configuration CC2530-LinkListen (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: MCU_H=<ioCC2530.h>; MRFI_CC2530
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\CC2530EM; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256.xcl
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk_api.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_freq.h nwk_ioctl.h nwk_join.h nwk_link.h nwk_mgmt.h nwk_ping.h nwk_pll.h nwk_security.h
  group hal/common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group hal/include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group hal/target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group hal/target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group hal/target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group mac/high_level
    ../../../../../Components/mac/high_level/: mac_cfg.c
    ../../../../../Components/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group mac/include
    ../../../../../Components/mac/include/: mac_api.h
  group mac/low_level/Common
    ../../../../../Components/mac/LOW_LEVEL/srf04/: mac_assert.h mac_rx.h
    ../../../../../Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c
  group mac/low_level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_radio_defs.c mac_rffrontend.c
    ../../../../../Components/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_radio_defs.h
  group osal
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group peer applications
    ../../../../../Components/bsp/drivers/code/: uart.c uart_intfc.c
  group peer applications/application
    ../startup/: chipcon_cstartup.s51
    ../../../Applications/: main_UART_Bridge.c OnBoard.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device Link
    Configuration/LinkTo/: smpl_config.dat
  group peer applications/Configuration/End Device Listen
    Configuration/LinkListen/: smpl_config.dat
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
