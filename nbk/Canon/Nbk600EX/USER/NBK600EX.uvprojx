# Keil uVision project NBK600EX.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CanStm32 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\IAP\CanStm32.bin ..\OBJ\CanStm32.axf
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\UCOSII\CORE;..\UCOSII\PORT;..\APP;..\UCOSII\CONFIG;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../APP/: STM32F10x.s
  group USER
    ../APP/: Flash.c FuncLayout.c KeyAdc.c KeyProc.c main.c Menu.c moto.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: Font.c LcdDriver.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/DMA/: dma.c
  group uC/OS-II CORE
    ../UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C os_tmr.c
    ../UCOSII/PORT/: os_cpu_a.asm
  group uC/OS-II PORT
    ../UCOSII/PORT/: os_cpu_c.c
  group uC/OS-II CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
    ../UCOSII/CORE/: uCOS_II.H
    ../UCOSII/PORT/: os_cpu.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group enc
    ../Enc_Dec/: encrypto.c
software components: CMSIS:CORE 4.3.0
